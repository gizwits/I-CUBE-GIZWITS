# IAR project Project.ewp, settings and files
configuration B-L475E-IOT01 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L475xx; MQTTCLIENT_PLATFORM_HEADER=MQTTCMSIS.h; ENABLE_IOT_INFO; ENABLE_IOT_ERROR; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; SENSOR; GAGENT_SERIAL_BAUDRATE=9600
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/BSP/B-L475E-IOT01; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lis3mdl; ../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../Drivers/BSP/Components/lsm6dsl; ../../../../../../Drivers/BSP/Components/vl53l0x; ../../../../../../Middlewares/Third_Party/AWS/include; ..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Common\Gizwits\Inc; ..\..\..\WiFi\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\es_wifi; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\cloud\gserver; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\cloud\m2m; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\core\gdns; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\core\nwk; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\core\timer; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\core\utilcode; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\crypto\aes; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\crypto\base64; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\dp; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\env; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\filetransmit\filepull; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\filetransmit\filepush; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\gatstartup; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\http; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\include; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\iof\iofcomm; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\iof\ioffs; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\iof\iofpthread; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\iof\iofserial; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\iof\ioftime; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\iof\net; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\local\authorization; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\local\commlocal; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\local\soclocal; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\net; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\socket\tcpsocket; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\lan\lanvirtual; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\ota\otawan; ..\..\..\..\..\..\Middlewares\Third_Party\gagentModule\gagent\simulator\simulatorcomm
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: B-L475E-IOT01.out
  ILINK.IlinkIcfFile: stm32l475xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Common
    ../../../../../Common/Gizwits/Src/: gagent_iot_test_basic_connectivity.c heap.c iot_flash_config.c network.c sensors_data.c timedate.c
  group Application/EWARM
    ./: startup_stm32l475xx.s
  group Application/gagent_wrapper
    ../../../../../../Middlewares/Third_Party/gagentModule/gagent/iof/iofcomm/: iofdev.c iofstring.c
    ../../../../../../Middlewares/Third_Party/gagentModule/gagent/iof/ioffs/: ioffile.c
    ../../../../../../Middlewares/Third_Party/gagentModule/gagent/iof/iofpthread/: iofipc.c iofpthread.c semaph.c
    ../../../../../../Middlewares/Third_Party/gagentModule/gagent/iof/net/: iofnet.c iofsocket.c
    ../../../../../../Middlewares/Third_Party/gagentModule/gagent/iof/iofserial/: iofserial.c
    ../../../../../../Middlewares/Third_Party/gagentModule/gagent/iof/ioftime/: ioftime.c
  group Application/User
    ../Src/: flash_l4.c main.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c vl53l0x_platform.c vl53l0x_proximity.c
  group Application/WIFI
    ../../../WiFi/Src/: es_wifi_io.c wifi.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_accelero.c stm32l475e_iot01_gyro.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_magneto.c stm32l475e_iot01_psensor.c stm32l475e_iot01_tsensor.c
  group Drivers/BSP/Components/ES_WIFI
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Drivers/BSP/Components/HTS221
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
  group Drivers/BSP/Components/LIS3MDL
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
  group Drivers/BSP/Components/LPS22HB
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c
  group Drivers/BSP/Components/LSM6DSL
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
  group Drivers/BSP/Components/vl53l0x
    ../../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/Third_Party/Gagent
    ../../../../../../Middlewares/Third_Party/Gagent/: Gagent_IAR.a
